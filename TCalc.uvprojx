# Keil uVision project TCalc.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TCalc +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --cpp11 --exceptions
  c include: .\src\CMSIS;.\src\Hardware;.\src\Internal;.\src\Lib\inc;.\src\Startup;.\src\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./src/CMSIS/: core_cm3.c system_stm32f10x.c
  group Internal
    ./src/Internal/: delay.cpp sys.cpp gpiopin.cpp usart.cpp pwm.cpp
  group Hardware
    ./src/Hardware/: lcdbase.cpp lcd1602.cpp lcd12864.cpp
  group Lib
    ./src/Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_usart.c
  group Startup
    ./src/Startup/: startup_stm32f10x_md.s
  group User
    ./src/User/: main.cpp stm32f10x_it.c
